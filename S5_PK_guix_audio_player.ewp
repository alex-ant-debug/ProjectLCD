# IAR project S5_PK_guix_audio_player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FS5D97E Renesas R7FS5D97E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: src; src/synergy_gen; synergy/ssp/inc; synergy/ssp/inc/bsp; synergy/ssp/inc/bsp/cmsis/Include; synergy/ssp/inc/driver/api; synergy/ssp/inc/driver/instances; synergy/ssp/inc/framework/api; synergy/ssp/inc/framework/el; synergy/ssp/inc/framework/instances; synergy/ssp/inc/framework/tes; synergy/ssp/src/framework/el/tx; synergy/ssp/src/framework/el/ux; synergy_cfg/ssp_cfg/bsp; synergy_cfg/ssp_cfg/driver; synergy_cfg/ssp_cfg/framework; synergy_cfg/ssp_cfg/framework/el; synergy_cfg/ssp_cfg/framework/tes; synergy/ssp/src/framework/el/tx/tx_src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: S5_PK_guix_audio_player.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group Synergy/Source Files/src
    src/: application_define.h application_payloads.h audio_thread_entry.c gui_thread_entry.c sf_audio_dummy_entry.c touch_thread_entry.c usb_thread_entry.c
  group Synergy/Source Files/src/guix_gen
    src/guix_gen/: audio_player.gxp audio_player_events.c audio_player_resources.c audio_player_resources.h audio_player_specifications.c audio_player_specifications.h
  group Synergy/Source Files/src/guix_raw
    src/guix_raw/: bar_vol.png bg_dk.png bg_pehmi1.png bg_sk.png btn_circle.png btn_down.png btn_eject.png btn_fwd.png btn_pause.png btn_play.png btn_restart.png btn_rew.png btn_up.png btn_vol_down.png btn_vol_up.png ico_logo.png ico_usb.png overlay_dk.png overlay_pehmi1.png overlay_sk.png Square721BT.ttf
  group Synergy/Source Files/src/lcd_setup
    src/lcd_setup/: lcd_setup.c lcd_setup.h
  group Synergy/Source Files/src/synergy_gen
    src/synergy_gen/: audio_thread.c audio_thread.h common_data.c common_data.h gui_thread.c gui_thread.h hal_data.c hal_data.h main.c message_data.c pin_data.c sf_audio_dummy.c sf_audio_dummy.h touch_thread.c touch_thread.h usb_thread.c usb_thread.h
  group Synergy/Source Files/synergy/board/s5d9_pk
    synergy/board/s5d9_pk/: bsp.h bsp_ethernet_phy.h bsp_init.c bsp_init.h bsp_leds.c bsp_leds.h bsp_qspi.c bsp_qspi.h
  group Synergy/Source Files/synergy/ssp/inc
    synergy/ssp/inc/: ssp_common_api.h ssp_features.h ssp_version.h
  group Synergy/Source Files/synergy/ssp/inc/bsp
    synergy/ssp/inc/bsp/: bsp_api.h
  group Synergy/Source Files/synergy/ssp/inc/bsp/cmsis/Include
    synergy/ssp/inc/bsp/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h core_cm23.h core_cm4.h mpu_armv7.h tz_context.h
  group Synergy/Source Files/synergy/ssp/inc/driver/api
    synergy/ssp/inc/driver/api/: r_cgc_api.h r_dac_api.h r_display_api.h r_elc_api.h r_external_irq_api.h r_fmi_api.h r_i2c_api.h r_input_capture_api.h r_ioport_api.h r_jpeg_decode_api.h r_spi_api.h r_timer_api.h r_transfer_api.h
  group Synergy/Source Files/synergy/ssp/inc/driver/instances
    synergy/ssp/inc/driver/instances/: r_cgc.h r_dac.h r_dtc.h r_elc.h r_fmi.h r_glcd.h r_gpt.h r_icu.h r_ioport.h r_jpeg_decode.h r_riic.h r_sci_spi.h
  group Synergy/Source Files/synergy/ssp/inc/framework/api
    synergy/ssp/inc/framework/api/: sf_audio_playback_api.h sf_audio_playback_hw_api.h sf_el_gx_api.h sf_external_irq_api.h sf_jpeg_decode_api.h sf_message_api.h sf_touch_panel_api.h
  group Synergy/Source Files/synergy/ssp/inc/framework/el
    synergy/ssp/inc/framework/el/: fx_api.h fx_port.h gx_api.h gx_display.h gx_port.h gx_utility.h tx_api.h tx_cmsis.h tx_initialize.h tx_port.h tx_trace.h ux_api.h ux_dcd_synergy.h ux_device_class_cdc_acm.h ux_device_class_hid.h ux_device_class_storage.h ux_device_stack.h ux_hcd_synergy.h ux_host_class_audio.h ux_host_class_cdc_acm.h ux_host_class_hid.h ux_host_class_hid_keyboard.h ux_host_class_hid_mouse.h ux_host_class_hid_remote_control.h ux_host_class_hub.h ux_host_class_storage.h ux_host_class_video.h ux_host_stack.h ux_port.h ux_system.h ux_utility.h
  group Synergy/Source Files/synergy/ssp/inc/framework/el/cm4_iar
    synergy/ssp/inc/framework/el/cm4_iar/: tx_port.h
  group Synergy/Source Files/synergy/ssp/inc/framework/instances
    synergy/ssp/inc/framework/instances/: sf_audio_playback.h sf_audio_playback_hw_dac.h sf_el_gx.h sf_external_irq.h sf_jpeg_decode.h sf_message.h sf_touch_panel_i2c.h
  group Synergy/Source Files/synergy/ssp/inc/framework/tes
    synergy/ssp/inc/framework/tes/: dave_base.h dave_driver.h dave_errorcodes.h dave_math.h dave_types.h
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/Device/RENESAS/S5D9/Include
    synergy/ssp/src/bsp/cmsis/Device/RENESAS/S5D9/Include/: S5D9.h system_S5D9.h
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/Device/RENESAS/S5D9/Source
    synergy/ssp/src/bsp/cmsis/Device/RENESAS/S5D9/Source/: startup_S5D9.c system_S5D9.c
  group Synergy/Source Files/synergy/ssp/src/bsp/cmsis/DSP_Lib/cm4_iar
    synergy/ssp/src/bsp/cmsis/DSP_Lib/cm4_iar/: libDSP_Lib.a
  group Synergy/Source Files/synergy/ssp/src/bsp/mcu/all
    synergy/ssp/src/bsp/mcu/all/: bsp_clocks.h bsp_common.c bsp_common.h bsp_common_analog.h bsp_common_leds.c bsp_common_leds.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_error_checking.h bsp_feature.h bsp_group_irq.h bsp_irq.c bsp_irq.h bsp_locking.c bsp_locking.h bsp_mcu_api.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c
  group Synergy/Source Files/synergy/ssp/src/bsp/mcu/s5d9
    synergy/ssp/src/bsp/mcu/s5d9/: bsp_analog.h bsp_cache.c bsp_cache.h bsp_clocks.c bsp_elc.h bsp_feature.c bsp_fmi_R7FS5D97E3A01CFC.c bsp_group_irq.c bsp_hw_locks.c bsp_mcu_info.h bsp_module_stop.c bsp_rom_registers.c
  group Synergy/Source Files/synergy/ssp/src/driver/r_cgc
    synergy/ssp/src/driver/r_cgc/: r_cgc.c r_cgc_private.h r_cgc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_cgc/hw
    synergy/ssp/src/driver/r_cgc/hw/: hw_cgc.h hw_cgc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dac
    synergy/ssp/src/driver/r_dac/: r_dac.c r_dac_private.h r_dac_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dac/hw
    synergy/ssp/src/driver/r_dac/hw/: hw_dac_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dac/hw/common
    synergy/ssp/src/driver/r_dac/hw/common/: hw_dac_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dtc
    synergy/ssp/src/driver/r_dtc/: r_dtc.c r_dtc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dtc/hw
    synergy/ssp/src/driver/r_dtc/hw/: hw_dtc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_dtc/hw/common
    synergy/ssp/src/driver/r_dtc/hw/common/: hw_dtc_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc
    synergy/ssp/src/driver/r_elc/: r_elc.c r_elc_private.h r_elc_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc/hw
    synergy/ssp/src/driver/r_elc/hw/: hw_elc_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_elc/hw/common
    synergy/ssp/src/driver/r_elc/hw/common/: hw_elc_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi
    synergy/ssp/src/driver/r_fmi/: r_fmi.c
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi/hw
    synergy/ssp/src/driver/r_fmi/hw/: hw_fmi_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_fmi/hw/common
    synergy/ssp/src/driver/r_fmi/hw/common/: hw_fmi_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_glcd
    synergy/ssp/src/driver/r_glcd/: r_glcd.c r_glcd_private.h r_glcd_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_glcd/hw/common
    synergy/ssp/src/driver/r_glcd/hw/common/: hw_glcd_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_gpt
    synergy/ssp/src/driver/r_gpt/: r_gpt.c r_gpt_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_gpt/hw
    synergy/ssp/src/driver/r_gpt/hw/: hw_gpt_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_gpt/hw/common
    synergy/ssp/src/driver/r_gpt/hw/common/: hw_gpt_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu
    synergy/ssp/src/driver/r_icu/: r_icu.c r_icu_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu/hw
    synergy/ssp/src/driver/r_icu/hw/: hw_icu_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_icu/hw/common
    synergy/ssp/src/driver/r_icu/hw/common/: hw_icu_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_ioport
    synergy/ssp/src/driver/r_ioport/: r_ioport.c r_ioport_private.h r_ioport_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_ioport/hw
    synergy/ssp/src/driver/r_ioport/hw/: hw_ioport_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_common
    synergy/ssp/src/driver/r_jpeg_common/: r_jpeg_common.c r_jpeg_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_decode
    synergy/ssp/src/driver/r_jpeg_decode/: r_jpeg_decode.c r_jpeg_decode_private.h r_jpeg_decode_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_decode/hw
    synergy/ssp/src/driver/r_jpeg_decode/hw/: hw_jpeg_decode_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_jpeg_decode/hw/common
    synergy/ssp/src/driver/r_jpeg_decode/hw/common/: hw_jpeg_decode_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_riic
    synergy/ssp/src/driver/r_riic/: r_riic.c r_riic_private.h r_riic_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_riic/hw
    synergy/ssp/src/driver/r_riic/hw/: hw_riic_private.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_riic/hw/common
    synergy/ssp/src/driver/r_riic/hw/common/: hw_riic_common.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_sci_spi
    synergy/ssp/src/driver/r_sci_spi/: r_sci_spi.c r_sci_spi_private_api.h
  group Synergy/Source Files/synergy/ssp/src/driver/r_sci_spi/hw
    synergy/ssp/src/driver/r_sci_spi/hw/: hw_sci_common.h hw_sci_spi_private.h
  group Synergy/Source Files/synergy/ssp/src/framework/el/fx/cm4_iar
    synergy/ssp/src/framework/el/fx/cm4_iar/: libfx.a
  group Synergy/Source Files/synergy/ssp/src/framework/el/gx/cm4_iar
    synergy/ssp/src/framework/el/gx/cm4_iar/: libgx.a
  group Synergy/Source Files/synergy/ssp/src/framework/el/tx/cm4_iar
    synergy/ssp/src/framework/el/tx/cm4_iar/: libtx.a
  group Synergy/Source Files/synergy/ssp/src/framework/el/tx/tx_src
    synergy/ssp/src/framework/el/tx/tx_src/: tx_thread.h tx_timer.h
  group Synergy/Source Files/synergy/ssp/src/framework/el/ux/cm4_iar
    synergy/ssp/src/framework/el/ux/cm4_iar/: libux.a
  group Synergy/Source Files/synergy/ssp/src/framework/el/ux_host_class_storage/cm4_iar
    synergy/ssp/src/framework/el/ux_host_class_storage/cm4_iar/: libux_host_class_storage.a
  group Synergy/Source Files/synergy/ssp/src/framework/sf_audio_playback
    synergy/ssp/src/framework/sf_audio_playback/: sf_audio_playback.c sf_audio_playback_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_audio_playback_hw_dac
    synergy/ssp/src/framework/sf_audio_playback_hw_dac/: sf_audio_playback_hw_dac.c sf_audio_playback_hw_dac_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_el_gx
    synergy/ssp/src/framework/sf_el_gx/: gx_display_driver_synergy_dave2d.c gx_display_driver_synergy_dave2d_8bit_palette.c sf_el_gx.c sf_el_gx_private.h sf_el_gx_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_el_ux
    synergy/ssp/src/framework/sf_el_ux/: usb_irq_veneer.c usbfs_irq_veneer.c ux_dcd_synergy_buffer_empty_interrupt.c ux_dcd_synergy_buffer_notready_interrupt.c ux_dcd_synergy_buffer_read.c ux_dcd_synergy_buffer_ready_interrupt.c ux_dcd_synergy_buffer_write.c ux_dcd_synergy_current_endpoint_change.c ux_dcd_synergy_data_buffersize.c ux_dcd_synergy_endpoint_create.c ux_dcd_synergy_endpoint_destroy.c ux_dcd_synergy_endpoint_nak_set.c ux_dcd_synergy_endpoint_reset.c ux_dcd_synergy_endpoint_stall.c ux_dcd_synergy_endpoint_status.c ux_dcd_synergy_fifo_port_change.c ux_dcd_synergy_fifo_read.c ux_dcd_synergy_fifoc_write.c ux_dcd_synergy_fifod_write.c ux_dcd_synergy_frame_number_get.c ux_dcd_synergy_function.c ux_dcd_synergy_initialize.c ux_dcd_synergy_initialize_complete.c ux_dcd_synergy_interrupt_handler.c ux_dcd_synergy_register_clear.c ux_dcd_synergy_register_read.c ux_dcd_synergy_register_set.c ux_dcd_synergy_register_write.c ux_dcd_synergy_transfer_abort.c ux_dcd_synergy_transfer_callback.c ux_dcd_synergy_transfer_request.c ux_dcd_synergy_uninitialize.c ux_device_stack.h ux_hcd_synergy_asynch_queue_process.c ux_hcd_synergy_asynch_queue_process_bemp.c ux_hcd_synergy_asynch_queue_process_brdy.c ux_hcd_synergy_asynch_queue_process_nrdy.c ux_hcd_synergy_asynch_queue_process_sign.c ux_hcd_synergy_asynch_schedule.c ux_hcd_synergy_asynchronous_endpoint_create.c ux_hcd_synergy_asynchronous_endpoint_destroy.c ux_hcd_synergy_buffer_empty_interrupt.c ux_hcd_synergy_buffer_notready_interrupt.c ux_hcd_synergy_buffer_read.c ux_hcd_synergy_buffer_ready_interrupt.c ux_hcd_synergy_buffer_write.c ux_hcd_synergy_bulk_endpoint_create.c ux_hcd_synergy_bulk_int_td_add.c ux_hcd_synergy_control_endpoint_create.c ux_hcd_synergy_control_td_add.c ux_hcd_synergy_controller_disable.c ux_hcd_synergy_current_endpoint_change.c ux_hcd_synergy_data_buffer_size.c ux_hcd_synergy_ed_obtain.c ux_hcd_synergy_ed_td_clean.c ux_hcd_synergy_endpoint_nak_set.c ux_hcd_synergy_endpoint_reset.c ux_hcd_synergy_entry.c ux_hcd_synergy_fifo_port_change.c ux_hcd_synergy_fifo_read.c ux_hcd_synergy_fifoc_write.c ux_hcd_synergy_fifod_write.c ux_hcd_synergy_frame_number_get.c ux_hcd_synergy_frame_number_set.c ux_hcd_synergy_initialize.c ux_hcd_synergy_interrupt_endpoint_create.c ux_hcd_synergy_interrupt_handler.c ux_hcd_synergy_iso_queue_process.c ux_hcd_synergy_iso_queue_process_bemp.c ux_hcd_synergy_iso_queue_process_brdy.c ux_hcd_synergy_iso_queue_process_nrdy.c ux_hcd_synergy_iso_schedule.c ux_hcd_synergy_iso_td_add.c ux_hcd_synergy_isochronous_endpoint_create.c ux_hcd_synergy_isochronous_td_obtain.c ux_hcd_synergy_least_traffic_list_get.c ux_hcd_synergy_periodic_endpoint_destroy.c ux_hcd_synergy_periodic_schedule.c ux_hcd_synergy_periodic_tree_create.c ux_hcd_synergy_port_disable.c ux_hcd_synergy_port_enable.c ux_hcd_synergy_port_reset.c ux_hcd_synergy_port_resume.c ux_hcd_synergy_port_status_get.c ux_hcd_synergy_port_suspend.c ux_hcd_synergy_power_down_port.c ux_hcd_synergy_power_on_port.c ux_hcd_synergy_power_root_hubs.c ux_hcd_synergy_register_clear.c ux_hcd_synergy_register_read.c ux_hcd_synergy_register_set.c ux_hcd_synergy_register_write.c ux_hcd_synergy_regular_td_obtain.c ux_hcd_synergy_request_bulk_transfer.c ux_hcd_synergy_request_control_transfer.c ux_hcd_synergy_request_interupt_transfer.c ux_hcd_synergy_request_isochronous_transfer.c ux_hcd_synergy_request_transfer.c ux_hcd_synergy_td_add.c ux_hcd_synergy_transfer_abort.c ux_hcd_synergy_uninitialize.c ux_host_stack.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_external_irq
    synergy/ssp/src/framework/sf_external_irq/: sf_external_irq.c sf_external_irq_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_jpeg_decode
    synergy/ssp/src/framework/sf_jpeg_decode/: sf_jpeg_decode.c sf_jpeg_decode_private.h sf_jpeg_decode_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_message
    synergy/ssp/src/framework/sf_message/: sf_message.c sf_message_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/sf_tes_2d_drw
    synergy/ssp/src/framework/sf_tes_2d_drw/: sf_tes_2d_drw_base.c sf_tes_2d_drw_base.h sf_tes_2d_drw_irq.c sf_tes_2d_drw_memory.c
  group Synergy/Source Files/synergy/ssp/src/framework/sf_touch_panel_i2c
    synergy/ssp/src/framework/sf_touch_panel_i2c/: sf_touch_panel_i2c.c sf_touch_panel_private_api.h
  group Synergy/Source Files/synergy/ssp/src/framework/tes/dave2d
    synergy/ssp/src/framework/tes/dave2d/: dave_64bitoperation.c dave_base.c dave_base.h dave_blit.c dave_box.c dave_box.h dave_circle.c dave_circle.h dave_context.c dave_context.h dave_curve.c dave_curve.h dave_dlist.c dave_dlist.h dave_driver.c dave_edge.c dave_edge.h dave_errorcodes.c dave_gradient.c dave_gradient.h dave_hardware.c dave_hardware.h dave_intern.h dave_line.c dave_line.h dave_math.c dave_memory.c dave_memory.h dave_pattern.c dave_pattern.h dave_perfcount.c dave_polyline.c dave_polyline.h dave_quad.c dave_quad.h dave_rbuffer.c dave_rbuffer.h dave_registermap.h dave_render.c dave_render.h dave_texture.c dave_texture.h dave_triangle.c dave_triangle.h dave_triarray.h dave_utility.c dave_utility.h dave_viewport.c dave_viewport.h dave_wedge.c dave_wedge.h
  group Synergy/Source Files/synergy/ssp_supplemental/touch_drivers/touch_panel_i2c_sx8654
    synergy/ssp_supplemental/touch_drivers/touch_panel_i2c_sx8654/: touch_panel_i2c_sx8654.c
